# Keil uVision project HelTec.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HelTec +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\src;..\..\Libraries\inc;..\..\other\.h;..\..\other\EPD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h OLED.c
    ../../other/adc/: adc.c
    ../../other/dma/: dma.c
    ../../other/ds18b20/: ds18b20.c
    ../../other/Exti/: bsp_exti.c
    ../../other/HC-SR01/: hc-rs04.c
    ../../other/iic/: iic.c
    ../../other/Led/: bsp_led.c
    ../../other/spi/: spi.c
    ../../other/time/: bsp_time.c
    ../../other/usart/: bsp_usart.c
    ../../other/Key/: bsp_key.c
    ../../other/delay/: delay.c
    ../../other/l298n/: l298n.c
    ../../other/A4988/: bsp_A4988.c
    ../../other/tracker/: tracker.c
    ../../other/SysTick/: bsp_SysTick.c
    ../../other/ESP8266/: bsp_esp8266.c
    ../../other/Common/: Common.c
    ../../other/ws2812b/: ws2812.c
  group DOC
    ../../Doc/: Readme.txt
